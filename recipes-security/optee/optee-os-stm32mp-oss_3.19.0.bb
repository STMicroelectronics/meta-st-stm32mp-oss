require optee-os-stm32mp-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.19.0"

SRCREV = "4adb4a1feaa06adfba13066c73830b1a8972b879"
# SRCREV = "1ee647035939e073a2e8dddb727c0f019cc035f1" # 3.18.0
# SRCREV = "f9e550142dd4b33ee1112f5dd64ffa94ba79cefa" # 3.17.0
# SRCREV = "d0b742d1564834dac903f906168d7357063d5459" # 3.16.0
# SRCREV = "6be0dbcaa11394a2ad5a46ac77e2f76e31a41722" # 3.15.0
# ------------------------------------------------
