require optee-client-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.15.0"

SRCREV = "182874320395787a389e5b0f7df02b32f3c0a1b0"
# SRCREV = "182874320395787a389e5b0f7df02b32f3c0a1b0" # 3.15.0
# ------------------------------------------------
