require optee-os-stm32mp-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "4.0.0"

SRCREV = "d75c42ff2847b090d5b1f11c49067cd41fcc2734"
# SRCREV = "2a5b1d1232f582056184367fb58a425ac7478ec6" # 4.0.0
# SRCREV = "001ace6655dd6bb9cbe31aa31b4ba69746e1a1d9" # 3.22.0
# SRCREV = "e8abbcfbdf63437a640d5fd87b7e191caab6445e" # 3.21.0
# SRCREV = "8e74d47616a20eaa23ca692f4bbbf917a236ed94" # 3.20.0
# SRCREV = "afacf356f9593a7f83cae9f96026824ec242ff52" # 3.19.0
# SRCREV = "1ee647035939e073a2e8dddb727c0f019cc035f1" # 3.18.0
# SRCREV = "f9e550142dd4b33ee1112f5dd64ffa94ba79cefa" # 3.17.0
# SRCREV = "d0b742d1564834dac903f906168d7357063d5459" # 3.16.0
# SRCREV = "6be0dbcaa11394a2ad5a46ac77e2f76e31a41722" # 3.15.0
# ------------------------------------------------
