require optee-client-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.21.0"

SRCREV = "8533e0e6329840ee96cf81b6453f257204227e6c"
# SRCREV = "8533e0e6329840ee96cf81b6453f257204227e6c" # 3.21.0
# SRCREV = "dd2d39b49975d2ada7870fe2b7f5a84d0d3860dc" # 3.20.0
# SRCREV = "140bf463046071d3ca5ebbde3fb21ee0854e1951" # 3.19.0
# SRCREV = "e7cba71cc6e2ecd02f412c7e9ee104f0a5dffc6f" # 3.18.0
# SRCREV = "9a337049c52495e5e16b4a94decaa3e58fce793e" # 3.17.0
# SRCREV = "06db73b3f3fdb8d23eceaedbc46c49c0b45fd1e2" # 3.16.0
# SRCREV = "182874320395787a389e5b0f7df02b32f3c0a1b0" # 3.15.0
# ------------------------------------------------
