require optee-client-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.17.0"

SRCREV = "9a337049c52495e5e16b4a94decaa3e58fce793e"
# SRCREV = "9a337049c52495e5e16b4a94decaa3e58fce793e" # 3.17.0
# SRCREV = "06db73b3f3fdb8d23eceaedbc46c49c0b45fd1e2" # 3.16.0
# SRCREV = "182874320395787a389e5b0f7df02b32f3c0a1b0" # 3.15.0
# ------------------------------------------------
