require optee-os-stm32mp-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.16.0"

SRCREV = "9ea4c6450405900ef264348d5de22f5fb96db16a"
# SRCREV = "d0b742d1564834dac903f906168d7357063d5459" # 3.16.0
# SRCREV = "6be0dbcaa11394a2ad5a46ac77e2f76e31a41722" # 3.15.0
# ------------------------------------------------
