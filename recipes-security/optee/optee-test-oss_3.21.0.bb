require optee-test-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.21.0"

SRCREV = "9c872638bc38324d8c65b9296ebec3d124e19466"
SRC_URI += "file://0001-no-error-deprecated-declarations.patch"
#SRCREV = "9c872638bc38324d8c65b9296ebec3d124e19466" # 3.21.0
#SRCREV = "5db8ab4c733d5b2f4afac3e9aef0a26634c4b444" # 3.20.0
#SRCREV = "ab9863cc187724e54c032b738c28bd6e9460a4db" # 3.19.0
#SRCREV = "da5282a011b40621a2cf7a296c11a35c833ed91b" # 3.18.0
#SRCREV = "44a31d02379bd8e50762caa5e1592ad81e3339af" # 3.17.0
#SRCREV = "1cf0e6d2bdd1145370033d4e182634458528579d" # 3.16.0
#SRCREV = "f88f69eb27beda52998de09cd89a7ee422da00d9" # 3.15.0
# ------------------------------------------------

