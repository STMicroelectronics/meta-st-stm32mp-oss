require optee-client-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.16.0"

SRCREV = "8b3f7fe3401f0853b4af32aed2c1b436f3a36377"
# SRCREV = "182874320395787a389e5b0f7df02b32f3c0a1b0" # 3.15.0
# ------------------------------------------------
