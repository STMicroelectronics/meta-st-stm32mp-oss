require optee-test-oss.inc
# Need to be aligned with the version of OPTEE-OS
# ------------------------------------------------
# to be updated
OPTEE_VERSION = "3.15.0"

SRCREV = "01322455ed79f3c9a862a222df194d962a2093f3"
#SRCREV = "f88f69eb27beda52998de09cd89a7ee422da00d9" # 3.15.0
# ------------------------------------------------

