LTTNGTOOLS_stm32mpcommon = ""

