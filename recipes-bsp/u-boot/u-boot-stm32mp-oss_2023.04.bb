require u-boot-stm32mp-oss.inc

# ------------------------------------------------
# to be updated
UBOOT_VERSION = "2023.04"
SRCREV = "fd4ed6b7e83ec3aea9a2ce21baea8ca9676f40dd"
#SRCREV = "fd4ed6b7e83ec3aea9a2ce21baea8ca9676f40dd" # 2023.04
#SRCREV = "62e2ad1ceafbfdf2c44d3dc1b6efc81e768a96b9" # 2023.01
#SRCREV = "4debc57a3da6c3f4d3f89a637e99206f4cea0a96" # 2022.10
#SRCREV = "e092e3250270a1016c877da7bdd9384f14b1321e" # 2022.07
#SRCREV = "e4b6ebd3de982ae7185dbf689a030e73fd06e0d2" # 2022.04
#SRCREV = "d637294e264adfeb29f390dfc393106fd4d41b17" # 2022.01
#SRCREV = "d80bb749fab53da72c4a0e09b8c2d2aaa3103c91" # 2021.10
#SRCREV = "840658b093976390e9537724f802281c9c8439f5" # 2021.07
#SRCREV = "b46dd116ce03e235f2a7d4843c6278e1da44b5e1" # 2021.04
#SRCREV = "c4fddedc48f336eabc4ce3f74940e6aa372de18c" # 2021.01
#SRCREV = "050acee119b3757fee3bd128f55d720fdd9bb890" # 2020.10
#SRCREV = "2f5fbb5b39f7b67044dda5c35e4a4b31685a3109" # 2020.07
# ------------------------------------------------
