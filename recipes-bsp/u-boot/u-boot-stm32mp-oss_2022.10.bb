require u-boot-stm32mp-oss.inc

# ------------------------------------------------
# to be updated
UBOOT_VERSION = "2022.01"
SRCREV = "558002a0f2230bedf6b38716f3ed86a92fc9010b"
#SRCREV = "d80bb749fab53da72c4a0e09b8c2d2aaa3103c91" # 2021.10
#SRCREV = "840658b093976390e9537724f802281c9c8439f5" # 2021.07
#SRCREV = "b46dd116ce03e235f2a7d4843c6278e1da44b5e1" # 2021.04
#SRCREV = "c4fddedc48f336eabc4ce3f74940e6aa372de18c" # 2021.01
#SRCREV = "050acee119b3757fee3bd128f55d720fdd9bb890" # 2020.10
#SRCREV = "2f5fbb5b39f7b67044dda5c35e4a4b31685a3109" # 2020.07
# ------------------------------------------------
