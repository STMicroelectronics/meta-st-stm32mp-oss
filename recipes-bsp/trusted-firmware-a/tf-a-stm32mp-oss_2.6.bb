require tf-a-stm32mp-oss.inc

# ------------------------------------------------
# to be updated
TFA_VERSION = "2.6"

SRCREV = "e537bcdedb16907ecab911e851c1dc4f35411b49"
#2.6 SRCREV = "a1f02f4f3daae7e21ee58b4c93ec3e46b8f28d15"
#2.5 SRCREV = "1e13c500a0351ac4b55d09a63f7008e2438550f8"
#2.4 SRCREV = "e2c509a39c6cc4dda8734e6509cdbe6e3603cdfc"
# ------------------------------------------------
