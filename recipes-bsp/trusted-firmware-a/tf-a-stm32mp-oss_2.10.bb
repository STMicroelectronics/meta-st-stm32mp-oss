require tf-a-stm32mp-oss.inc

# ------------------------------------------------
# to be updated
TFA_VERSION = "2.10"

SRCREV = "e7781c84e9b36c948aa84721a09d96ee9e2b6eef"
#2.9 SRCREV = "d3e71ead6ea5bc3555ac90a446efec84ef6c6122"
#2.8 SRCREV = "9881bb93a3bc0a3ea37e9f093e09ab4b360a9e48"
#2.7 SRCREV = "35f4c7295bafeb32c8bcbdfb6a3f2e74a57e732b"
#2.6 SRCREV = "a1f02f4f3daae7e21ee58b4c93ec3e46b8f28d15"
#2.5 SRCREV = "1e13c500a0351ac4b55d09a63f7008e2438550f8"
#2.4 SRCREV = "e2c509a39c6cc4dda8734e6509cdbe6e3603cdfc"
# ------------------------------------------------
