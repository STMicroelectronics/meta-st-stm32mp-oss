require tf-a-stm32mp-oss.inc

# ------------------------------------------------
# to be updated
TFA_VERSION = "2.7"

SRCREV = "c19116dd61068d70808ff71efbe914e50a5346e3"
#2.7 SRCREV = "35f4c7295bafeb32c8bcbdfb6a3f2e74a57e732b"
#2.6 SRCREV = "a1f02f4f3daae7e21ee58b4c93ec3e46b8f28d15"
#2.5 SRCREV = "1e13c500a0351ac4b55d09a63f7008e2438550f8"
#2.4 SRCREV = "e2c509a39c6cc4dda8734e6509cdbe6e3603cdfc"
# ------------------------------------------------
