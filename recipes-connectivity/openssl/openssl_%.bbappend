PACKAGECONFIG_remove = " cryptodev-linux"
